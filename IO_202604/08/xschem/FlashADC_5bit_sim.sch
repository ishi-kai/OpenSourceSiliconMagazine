v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 290 -1270 290 -1250 {lab=VDD}
N 290 -1130 290 -1110 {lab=GND}
N 210 -1160 230 -1160 {lab=Vref0}
N 210 -1220 230 -1220 {lab=Vin}
N 330 -1130 330 -1110 {lab=Vbias}
N 390 -1190 410 -1190 {lab=Vout0}
N 290 -1090 290 -1070 {lab=VDD}
N 290 -950 290 -930 {lab=GND}
N 210 -980 230 -980 {lab=Vref1}
N 210 -1040 230 -1040 {lab=Vin}
N 330 -950 330 -930 {lab=Vbias}
N 390 -1010 410 -1010 {lab=Vout1}
N 290 -910 290 -890 {lab=VDD}
N 290 -770 290 -750 {lab=GND}
N 210 -800 230 -800 {lab=Vref2}
N 210 -860 230 -860 {lab=Vin}
N 330 -770 330 -750 {lab=Vbias}
N 390 -830 410 -830 {lab=Vout2}
N 290 -730 290 -710 {lab=VDD}
N 290 -590 290 -570 {lab=GND}
N 210 -620 230 -620 {lab=Vref3}
N 210 -680 230 -680 {lab=Vin}
N 330 -590 330 -570 {lab=Vbias}
N 390 -650 410 -650 {lab=Vout3}
N 290 -550 290 -530 {lab=VDD}
N 290 -410 290 -390 {lab=GND}
N 210 -440 230 -440 {lab=Vref4}
N 210 -500 230 -500 {lab=Vin}
N 330 -410 330 -390 {lab=Vbias}
N 390 -470 410 -470 {lab=Vout4}
N 290 -370 290 -350 {lab=VDD}
N 290 -230 290 -210 {lab=GND}
N 210 -260 230 -260 {lab=Vref5}
N 210 -320 230 -320 {lab=Vin}
N 330 -230 330 -210 {lab=Vbias}
N 390 -290 410 -290 {lab=Vout5}
N 290 -190 290 -170 {lab=VDD}
N 290 -50 290 -30 {lab=GND}
N 210 -80 230 -80 {lab=Vref6}
N 210 -140 230 -140 {lab=Vin}
N 330 -50 330 -30 {lab=Vbias}
N 390 -110 410 -110 {lab=Vout6}
N 290 -10 290 10 {lab=VDD}
N 290 130 290 150 {lab=GND}
N 210 100 230 100 {lab=Vref7}
N 210 40 230 40 {lab=Vin}
N 330 130 330 150 {lab=Vbias}
N 390 70 410 70 {lab=Vout7}
N 290 170 290 190 {lab=VDD}
N 290 310 290 330 {lab=GND}
N 210 280 230 280 {lab=Vref8}
N 210 220 230 220 {lab=Vin}
N 330 310 330 330 {lab=Vbias}
N 390 250 410 250 {lab=Vout8}
N 290 350 290 370 {lab=VDD}
N 290 490 290 510 {lab=GND}
N 210 460 230 460 {lab=Vref9}
N 210 400 230 400 {lab=Vin}
N 330 490 330 510 {lab=Vbias}
N 390 430 410 430 {lab=Vout9}
N 290 530 290 550 {lab=VDD}
N 290 670 290 690 {lab=GND}
N 210 640 230 640 {lab=Vref10}
N 210 580 230 580 {lab=Vin}
N 330 670 330 690 {lab=Vbias}
N 390 610 410 610 {lab=Vout10}
N 290 710 290 730 {lab=VDD}
N 290 850 290 870 {lab=GND}
N 210 820 230 820 {lab=Vref11}
N 210 760 230 760 {lab=Vin}
N 330 850 330 870 {lab=Vbias}
N 390 790 410 790 {lab=Vout11}
N 290 890 290 910 {lab=VDD}
N 290 1030 290 1050 {lab=GND}
N 210 1000 230 1000 {lab=Vref12}
N 210 940 230 940 {lab=Vin}
N 330 1030 330 1050 {lab=Vbias}
N 390 970 410 970 {lab=Vout12}
N 290 1070 290 1090 {lab=VDD}
N 290 1210 290 1230 {lab=GND}
N 210 1180 230 1180 {lab=Vref13}
N 210 1120 230 1120 {lab=Vin}
N 330 1210 330 1230 {lab=Vbias}
N 390 1150 410 1150 {lab=Vout13}
N 290 1250 290 1270 {lab=VDD}
N 290 1390 290 1410 {lab=GND}
N 210 1360 230 1360 {lab=Vref14}
N 210 1300 230 1300 {lab=Vin}
N 330 1390 330 1410 {lab=Vbias}
N 390 1330 410 1330 {lab=Vout14}
N 290 1430 290 1450 {lab=VDD}
N 290 1570 290 1590 {lab=GND}
N 210 1540 230 1540 {lab=Vref15}
N 210 1480 230 1480 {lab=Vin}
N 330 1570 330 1590 {lab=Vbias}
N 390 1510 410 1510 {lab=Vout15}
N -140 -1160 -120 -1160 {lab=Vref0}
N -140 -980 -120 -980 {lab=Vref1}
N -140 -800 -120 -800 {lab=Vref2}
N -140 -620 -120 -620 {lab=Vref3}
N -140 -440 -120 -440 {lab=Vref4}
N -140 -260 -120 -260 {lab=Vref5}
N -140 -80 -120 -80 {lab=Vref6}
N -140 100 -120 100 {lab=Vref7}
N -140 280 -120 280 {lab=Vref8}
N -140 460 -120 460 {lab=Vref9}
N -140 640 -120 640 {lab=Vref10}
N -140 820 -120 820 {lab=Vref11}
N -140 1000 -120 1000 {lab=Vref12}
N -140 1180 -120 1180 {lab=Vref13}
N -140 1360 -120 1360 {lab=Vref14}
N -140 1540 -120 1540 {lab=Vref15}
N -120 -1160 -0 -1160 {lab=Vref0}
N -0 -1200 0 -1160 {lab=Vref0}
N -0 -1160 0 -1110 {lab=Vref0}
N -120 -980 -0 -980 {lab=Vref1}
N -0 -1030 0 -980 {lab=Vref1}
N -0 -980 0 -930 {lab=Vref1}
N -120 -800 0 -800 {lab=Vref2}
N -0 -850 0 -800 {lab=Vref2}
N 0 -800 0 -750 {lab=Vref2}
N -120 -620 -0 -620 {lab=Vref3}
N 0 -670 0 -620 {lab=Vref3}
N 0 -620 0 -570 {lab=Vref3}
N -120 -440 -0 -440 {lab=Vref4}
N -0 -490 0 -440 {lab=Vref4}
N 0 -440 0 -390 {lab=Vref4}
N -120 -260 0 -260 {lab=Vref5}
N -0 -310 0 -210 {lab=Vref5}
N 0 -130 -0 -30 {lab=Vref6}
N -120 -80 -0 -80 {lab=Vref6}
N 0 50 0 140 {lab=Vref7}
N -120 100 -0 100 {lab=Vref7}
N 0 220 0 320 {lab=Vref8}
N -120 280 -0 280 {lab=Vref8}
N 0 400 -0 520 {lab=Vref9}
N -120 460 -0 460 {lab=Vref9}
N 0 600 0 690 {lab=Vref10}
N -120 640 0 640 {lab=Vref10}
N 0 770 0 870 {lab=Vref11}
N -110 820 -0 820 {lab=Vref11}
N -120 820 -110 820 {lab=Vref11}
N 0 950 0 1050 {lab=Vref12}
N -120 1000 -0 1000 {lab=Vref12}
N -0 1130 0 1230 {lab=Vref13}
N -120 1180 -0 1180 {lab=Vref13}
N -120 1360 -0 1360 {lab=Vref14}
N 0 1320 0 1410 {lab=Vref14}
N -0 1310 -0 1320 {lab=Vref14}
N -0 1490 0 1600 {lab=Vref15}
N -120 1540 -0 1540 {lab=Vref15}
N -0 -1300 0 -1280 {lab=GND}
N -430 -1300 -430 -1290 {lab=VDD}
N -430 -1230 -430 -1220 {lab=GND}
N -320 -1310 -320 -1290 {lab=Vref}
N -320 -1230 -320 -1220 {lab=GND}
N -320 -1220 -320 -1210 {lab=GND}
N -430 -1140 -430 -1130 {lab=Vbias}
N -430 -1070 -430 -1060 {lab=GND}
N -430 -1150 -430 -1140 {lab=Vbias}
N -320 -1140 -320 -1130 {lab=Vin}
N -320 -1070 -320 -1060 {lab=GND}
N -320 -1150 -320 -1140 {lab=Vin}
N 290 1610 290 1630 {lab=VDD}
N 290 1750 290 1770 {lab=GND}
N 210 1720 230 1720 {lab=Vref16}
N 210 1660 230 1660 {lab=Vin}
N 330 1750 330 1770 {lab=Vbias}
N 390 1690 410 1690 {lab=Vout16}
N 290 1790 290 1810 {lab=VDD}
N 290 1930 290 1950 {lab=GND}
N 210 1900 230 1900 {lab=Vref17}
N 210 1840 230 1840 {lab=Vin}
N 330 1930 330 1950 {lab=Vbias}
N 390 1870 410 1870 {lab=Vout17}
N 290 1970 290 1990 {lab=VDD}
N 290 2110 290 2130 {lab=GND}
N 210 2080 230 2080 {lab=Vref18}
N 210 2020 230 2020 {lab=Vin}
N 330 2110 330 2130 {lab=Vbias}
N 390 2050 410 2050 {lab=Vout18}
N 290 2150 290 2170 {lab=VDD}
N 290 2290 290 2310 {lab=GND}
N 210 2260 230 2260 {lab=Vref19}
N 210 2200 230 2200 {lab=Vin}
N 330 2290 330 2310 {lab=Vbias}
N 390 2230 410 2230 {lab=Vout19}
N 290 2330 290 2350 {lab=VDD}
N 290 2470 290 2490 {lab=GND}
N 210 2440 230 2440 {lab=Vref20}
N 210 2380 230 2380 {lab=Vin}
N 330 2470 330 2490 {lab=Vbias}
N 390 2410 410 2410 {lab=Vout20}
N 290 2510 290 2530 {lab=VDD}
N 290 2650 290 2670 {lab=GND}
N 210 2620 230 2620 {lab=Vref21}
N 210 2560 230 2560 {lab=Vin}
N 330 2650 330 2670 {lab=Vbias}
N 390 2590 410 2590 {lab=Vout21}
N 290 2690 290 2710 {lab=VDD}
N 290 2830 290 2850 {lab=GND}
N 210 2800 230 2800 {lab=Vref22}
N 210 2740 230 2740 {lab=Vin}
N 330 2830 330 2850 {lab=Vbias}
N 390 2770 410 2770 {lab=Vout22}
N 290 2870 290 2890 {lab=VDD}
N 290 3010 290 3030 {lab=GND}
N 210 2980 230 2980 {lab=Vref23}
N 210 2920 230 2920 {lab=Vin}
N 330 3010 330 3030 {lab=Vbias}
N 390 2950 410 2950 {lab=Vout23}
N 290 3050 290 3070 {lab=VDD}
N 290 3190 290 3210 {lab=GND}
N 210 3160 230 3160 {lab=Vref24}
N 210 3100 230 3100 {lab=Vin}
N 330 3190 330 3210 {lab=Vbias}
N 390 3130 410 3130 {lab=Vout24}
N 290 3230 290 3250 {lab=VDD}
N 290 3370 290 3390 {lab=GND}
N 210 3340 230 3340 {lab=Vref25}
N 210 3280 230 3280 {lab=Vin}
N 330 3370 330 3390 {lab=Vbias}
N 390 3310 410 3310 {lab=Vout25}
N 290 3410 290 3430 {lab=VDD}
N 290 3550 290 3570 {lab=GND}
N 210 3520 230 3520 {lab=Vref26}
N 210 3460 230 3460 {lab=Vin}
N 330 3550 330 3570 {lab=Vbias}
N 390 3490 410 3490 {lab=Vout26}
N 290 3590 290 3610 {lab=VDD}
N 290 3730 290 3750 {lab=GND}
N 210 3700 230 3700 {lab=Vref27}
N 210 3640 230 3640 {lab=Vin}
N 330 3730 330 3750 {lab=Vbias}
N 390 3670 410 3670 {lab=Vout27}
N 290 3770 290 3790 {lab=VDD}
N 290 3910 290 3930 {lab=GND}
N 210 3880 230 3880 {lab=Vref28}
N 210 3820 230 3820 {lab=Vin}
N 330 3910 330 3930 {lab=Vbias}
N 390 3850 410 3850 {lab=Vout28}
N 290 3950 290 3970 {lab=VDD}
N 290 4090 290 4110 {lab=GND}
N 210 4060 230 4060 {lab=Vref29}
N 210 4000 230 4000 {lab=Vin}
N 330 4090 330 4110 {lab=Vbias}
N 390 4030 410 4030 {lab=Vout29}
N 290 4130 290 4150 {lab=VDD}
N 290 4270 290 4290 {lab=GND}
N 210 4240 230 4240 {lab=Vref30}
N 210 4180 230 4180 {lab=Vin}
N 330 4270 330 4290 {lab=Vbias}
N 390 4210 410 4210 {lab=Vout30}
N 290 4310 290 4330 {lab=VDD}
N 290 4450 290 4470 {lab=GND}
N 210 4420 230 4420 {lab=Vref31}
N 210 4360 230 4360 {lab=Vin}
N 330 4450 330 4470 {lab=Vbias}
N 390 4390 410 4390 {lab=Vout31}
N -140 1720 -120 1720 {lab=Vref16}
N -140 1900 -120 1900 {lab=Vref17}
N -140 2080 -120 2080 {lab=Vref18}
N -140 2260 -120 2260 {lab=Vref19}
N -140 2440 -120 2440 {lab=Vref20}
N -140 2620 -120 2620 {lab=Vref21}
N -140 2800 -120 2800 {lab=Vref22}
N -140 2980 -120 2980 {lab=Vref23}
N -140 3160 -120 3160 {lab=Vref24}
N -140 3340 -120 3340 {lab=Vref25}
N -140 3520 -120 3520 {lab=Vref26}
N -140 3700 -120 3700 {lab=Vref27}
N -140 3880 -120 3880 {lab=Vref28}
N -140 4060 -120 4060 {lab=Vref29}
N -140 4240 -120 4240 {lab=Vref30}
N -140 4420 -120 4420 {lab=Vref31}
N -120 1720 0 1720 {lab=Vref16}
N 0 1680 0 1720 {lab=Vref16}
N 0 1720 0 1770 {lab=Vref16}
N -120 1900 0 1900 {lab=Vref17}
N 0 1850 0 1900 {lab=Vref17}
N 0 1900 0 1950 {lab=Vref17}
N -120 2080 0 2080 {lab=Vref18}
N 0 2030 0 2080 {lab=Vref18}
N 0 2080 0 2130 {lab=Vref18}
N -120 2260 0 2260 {lab=Vref19}
N 0 2210 0 2260 {lab=Vref19}
N 0 2260 0 2310 {lab=Vref19}
N -120 2440 0 2440 {lab=Vref20}
N 0 2390 0 2440 {lab=Vref20}
N 0 2440 0 2490 {lab=Vref20}
N -120 2620 0 2620 {lab=Vref21}
N 0 2570 0 2670 {lab=Vref21}
N 0 2750 0 2850 {lab=Vref22}
N -120 2800 0 2800 {lab=Vref22}
N 0 2930 0 3020 {lab=Vref23}
N -120 2980 0 2980 {lab=Vref23}
N 0 3100 0 3200 {lab=Vref24}
N -120 3160 0 3160 {lab=Vref24}
N 0 3280 0 3400 {lab=Vref25}
N -120 3340 0 3340 {lab=Vref25}
N 0 3480 0 3570 {lab=Vref26}
N -120 3520 0 3520 {lab=Vref26}
N 0 3650 0 3750 {lab=Vref27}
N -110 3700 0 3700 {lab=Vref27}
N -120 3700 -110 3700 {lab=Vref27}
N 0 3830 0 3930 {lab=Vref28}
N -120 3880 0 3880 {lab=Vref28}
N 0 4010 0 4110 {lab=Vref29}
N -120 4060 0 4060 {lab=Vref29}
N -120 4240 0 4240 {lab=Vref30}
N 0 4200 0 4290 {lab=Vref30}
N 0 4190 0 4200 {lab=Vref30}
N 0 4370 0 4480 {lab=Vref31}
N -120 4420 0 4420 {lab=Vref31}
N 0 4560 0 4580 {lab=Vref}
N 690 -1260 690 -1240 {lab=VDD}
N 690 -1120 690 -1100 {lab=GND}
N 600 -1160 620 -1160 {lab=Vout0}
N 600 -1200 620 -1200 {lab=Vout1}
N 770 -1180 790 -1180 {lab=CN0}
N 690 -1080 690 -1060 {lab=VDD}
N 690 -940 690 -920 {lab=GND}
N 600 -980 620 -980 {lab=Vout1}
N 600 -1020 620 -1020 {lab=Vout2}
N 770 -1000 790 -1000 {lab=CN1}
N 690 -890 690 -870 {lab=VDD}
N 690 -750 690 -730 {lab=GND}
N 600 -790 620 -790 {lab=Vout2}
N 600 -830 620 -830 {lab=Vout3}
N 770 -810 790 -810 {lab=CN2}
N 690 -710 690 -690 {lab=VDD}
N 690 -570 690 -550 {lab=GND}
N 600 -610 620 -610 {lab=Vout3}
N 600 -650 620 -650 {lab=Vout4}
N 770 -630 790 -630 {lab=CN3}
N 690 -530 690 -510 {lab=VDD}
N 690 -390 690 -370 {lab=GND}
N 600 -430 620 -430 {lab=Vout4}
N 600 -470 620 -470 {lab=Vout5}
N 770 -450 790 -450 {lab=CN4}
N 690 -350 690 -330 {lab=VDD}
N 690 -210 690 -190 {lab=GND}
N 600 -250 620 -250 {lab=Vout5}
N 600 -290 620 -290 {lab=Vout6}
N 770 -270 790 -270 {lab=CN5}
N 690 -170 690 -150 {lab=VDD}
N 690 -30 690 -10 {lab=GND}
N 600 -70 620 -70 {lab=Vout6}
N 600 -110 620 -110 {lab=Vout7}
N 770 -90 790 -90 {lab=CN6}
N 690 10 690 30 {lab=VDD}
N 690 150 690 170 {lab=GND}
N 600 110 620 110 {lab=Vout7}
N 600 70 620 70 {lab=Vout8}
N 770 90 790 90 {lab=CN7}
N 690 190 690 210 {lab=VDD}
N 690 330 690 350 {lab=GND}
N 600 290 620 290 {lab=Vout8}
N 600 250 620 250 {lab=Vout9}
N 770 270 790 270 {lab=CN8}
N 690 370 690 390 {lab=VDD}
N 690 510 690 530 {lab=GND}
N 600 470 620 470 {lab=Vout9}
N 600 430 620 430 {lab=Vout10}
N 770 450 790 450 {lab=CN9}
N 690 550 690 570 {lab=VDD}
N 690 690 690 710 {lab=GND}
N 600 650 620 650 {lab=Vout10}
N 600 610 620 610 {lab=Vout11}
N 770 630 790 630 {lab=CN10}
N 690 730 690 750 {lab=VDD}
N 690 870 690 890 {lab=GND}
N 600 830 620 830 {lab=Vout11}
N 600 790 620 790 {lab=Vout12}
N 770 810 790 810 {lab=CN11}
N 690 910 690 930 {lab=VDD}
N 690 1050 690 1070 {lab=GND}
N 600 1010 620 1010 {lab=Vout12}
N 600 970 620 970 {lab=Vout13}
N 770 990 790 990 {lab=CN12}
N 690 1100 690 1120 {lab=VDD}
N 690 1240 690 1260 {lab=GND}
N 600 1200 620 1200 {lab=Vout13}
N 600 1160 620 1160 {lab=Vout14}
N 770 1180 790 1180 {lab=CN13}
N 690 1280 690 1300 {lab=VDD}
N 690 1420 690 1440 {lab=GND}
N 600 1380 620 1380 {lab=Vout14}
N 600 1340 620 1340 {lab=Vout15}
N 770 1360 790 1360 {lab=CN14}
N 690 1460 690 1480 {lab=VDD}
N 690 1600 690 1620 {lab=GND}
N 600 1560 620 1560 {lab=Vout15}
N 600 1520 620 1520 {lab=Vout16}
N 770 1540 790 1540 {lab=CN15}
N 690 1640 690 1660 {lab=VDD}
N 690 1780 690 1800 {lab=GND}
N 600 1740 620 1740 {lab=Vout16}
N 600 1700 620 1700 {lab=Vout17}
N 770 1720 790 1720 {lab=CN16}
N 690 1820 690 1840 {lab=VDD}
N 690 1960 690 1980 {lab=GND}
N 600 1920 620 1920 {lab=Vout17}
N 600 1880 620 1880 {lab=Vout18}
N 770 1900 790 1900 {lab=CN17}
N 690 2000 690 2020 {lab=VDD}
N 690 2140 690 2160 {lab=GND}
N 600 2100 620 2100 {lab=Vout18}
N 600 2060 620 2060 {lab=Vout19}
N 770 2080 790 2080 {lab=CN18}
N 690 2180 690 2200 {lab=VDD}
N 690 2320 690 2340 {lab=GND}
N 600 2280 620 2280 {lab=Vout19}
N 600 2240 620 2240 {lab=Vout20}
N 770 2260 790 2260 {lab=CN19}
N 690 2360 690 2380 {lab=VDD}
N 690 2500 690 2520 {lab=GND}
N 600 2460 620 2460 {lab=Vout20}
N 600 2420 620 2420 {lab=Vout21}
N 770 2440 790 2440 {lab=CN20}
N 690 2540 690 2560 {lab=VDD}
N 690 2680 690 2700 {lab=GND}
N 600 2640 620 2640 {lab=Vout21}
N 600 2600 620 2600 {lab=Vout22}
N 770 2620 790 2620 {lab=CN21}
N 690 2720 690 2740 {lab=VDD}
N 690 2860 690 2880 {lab=GND}
N 600 2820 620 2820 {lab=Vout22}
N 600 2780 620 2780 {lab=Vout23}
N 770 2800 790 2800 {lab=CN22}
N 690 2900 690 2920 {lab=VDD}
N 690 3040 690 3060 {lab=GND}
N 600 3000 620 3000 {lab=Vout23}
N 600 2960 620 2960 {lab=Vout24}
N 770 2980 790 2980 {lab=CN23}
N 690 3080 690 3100 {lab=VDD}
N 690 3220 690 3240 {lab=GND}
N 600 3180 620 3180 {lab=Vout24}
N 600 3140 620 3140 {lab=Vout25}
N 770 3160 790 3160 {lab=CN24}
N 690 3260 690 3280 {lab=VDD}
N 690 3400 690 3420 {lab=GND}
N 600 3360 620 3360 {lab=Vout25}
N 600 3320 620 3320 {lab=Vout26}
N 770 3340 790 3340 {lab=CN25}
N 690 3440 690 3460 {lab=VDD}
N 690 3580 690 3600 {lab=GND}
N 600 3540 620 3540 {lab=Vout26}
N 600 3500 620 3500 {lab=Vout27}
N 770 3520 790 3520 {lab=CN26}
N 690 3620 690 3640 {lab=VDD}
N 690 3760 690 3780 {lab=GND}
N 600 3720 620 3720 {lab=Vout27}
N 600 3680 620 3680 {lab=Vout28}
N 770 3700 790 3700 {lab=CN27}
N 690 3800 690 3820 {lab=VDD}
N 690 3940 690 3960 {lab=GND}
N 600 3900 620 3900 {lab=Vout28}
N 600 3860 620 3860 {lab=Vout29}
N 770 3880 790 3880 {lab=CN28}
N 690 3980 690 4000 {lab=VDD}
N 690 4120 690 4140 {lab=GND}
N 600 4080 620 4080 {lab=Vout29}
N 600 4040 620 4040 {lab=Vout30}
N 770 4060 790 4060 {lab=CN29}
N 690 4160 690 4180 {lab=VDD}
N 690 4300 690 4320 {lab=GND}
N 600 4260 620 4260 {lab=Vout30}
N 600 4220 620 4220 {lab=Vout31}
N 770 4240 790 4240 {lab=CN30}
N 1110 -520 1110 -500 {lab=GND}
N 1110 -1220 1110 -1200 {lab=VDD}
N 1210 -1100 1230 -1100 {lab=Out0}
N 1210 -1080 1230 -1080 {lab=Out1}
N 1210 -1060 1230 -1060 {lab=Out2}
N 1210 -1040 1220 -1040 {lab=Out3}
N 1220 -1040 1230 -1040 {lab=Out3}
N 1210 -1020 1230 -1020 {lab=Out4}
N 980 -1170 1000 -1170 {lab=CN0}
N 980 -1150 1000 -1150 {lab=CN1}
N 980 -1130 1000 -1130 {lab=CN2}
N 980 -1110 1000 -1110 {lab=CN3}
N 980 -1090 1000 -1090 {lab=CN4}
N 980 -1070 1000 -1070 {lab=CN5}
N 980 -1050 1000 -1050 {lab=CN6}
N 980 -1030 1000 -1030 {lab=CN7}
N 980 -1010 1000 -1010 {lab=CN8}
N 980 -990 1000 -990 {lab=CN9}
N 980 -970 1000 -970 {lab=CN10}
N 980 -950 1000 -950 {lab=CN11}
N 980 -930 1000 -930 {lab=CN12}
N 980 -910 1000 -910 {lab=CN13}
N 980 -890 1000 -890 {lab=CN14}
N 980 -690 1000 -690 {lab=CN24}
N 980 -670 1000 -670 {lab=CN25}
N 980 -650 1000 -650 {lab=CN26}
N 980 -630 1000 -630 {lab=CN27}
N 980 -610 1000 -610 {lab=CN28}
N 980 -590 1000 -590 {lab=CN29}
N 980 -570 1000 -570 {lab=CN30}
N 980 -550 1000 -550 {lab=CN31}
N 980 -870 1000 -870 {lab=CN15}
N 980 -850 1000 -850 {lab=CN16}
N 980 -830 1000 -830 {lab=CN17}
N 980 -810 1000 -810 {lab=CN18}
N 980 -790 1000 -790 {lab=CN19}
N 980 -770 1000 -770 {lab=CN20}
N 980 -750 1000 -750 {lab=CN21}
N 980 -730 1000 -730 {lab=CN22}
N 980 -710 1000 -710 {lab=CN23}
N 690 4340 690 4360 {lab=VDD}
N 690 4480 690 4500 {lab=GND}
N 600 4440 620 4440 {lab=Vout31}
N 600 4400 620 4400 {lab=GND}
N 770 4420 790 4420 {lab=CN31}
N -60 -1280 -60 -1270 {lab=GND}
N -60 -1280 40 -1280 {lab=GND}
N 40 -1280 40 -1270 {lab=GND}
N 40 -1210 40 -1200 {lab=Vref0}
N -60 -1200 40 -1200 {lab=Vref0}
N -60 -1210 -60 -1200 {lab=Vref0}
N -60 4550 -60 4560 {lab=Vref}
N -60 4560 40 4560 {lab=Vref}
N 40 4550 40 4560 {lab=Vref}
N 40 4480 40 4490 {lab=Vref31}
N -60 4480 40 4480 {lab=Vref31}
N -60 4480 -60 4490 {lab=Vref31}
C {design/IO_Self-published/Vref_resistor.sym} 0 -1080 0 0 {name=x0}
C {design/IO_Self-published/Vref_resistor.sym} 0 -890 0 0 {name=x1}
C {design/IO_Self-published/Vref_resistor.sym} 0 -710 0 0 {name=x2}
C {design/IO_Self-published/Vref_resistor.sym} 0 -530 0 0 {name=x3}
C {design/IO_Self-published/Vref_resistor.sym} 0 -350 0 0 {name=x4}
C {design/IO_Self-published/Vref_resistor.sym} 0 -170 0 0 {name=x5}
C {design/IO_Self-published/Vref_resistor.sym} 0 10 0 0 {name=x6}
C {design/IO_Self-published/Vref_resistor.sym} 0 180 0 0 {name=x7}
C {design/IO_Self-published/Vref_resistor.sym} 0 360 0 0 {name=x8}
C {design/IO_Self-published/Vref_resistor.sym} 0 560 0 0 {name=x9}
C {design/IO_Self-published/Vref_resistor.sym} 0 730 0 0 {name=x10}
C {design/IO_Self-published/Vref_resistor.sym} 0 910 0 0 {name=x11}
C {design/IO_Self-published/Vref_resistor.sym} 0 1090 0 0 {name=x12}
C {design/IO_Self-published/Vref_resistor.sym} 0 1270 0 0 {name=x13}
C {design/IO_Self-published/Vref_resistor.sym} 0 1450 0 0 {name=x14}
C {design/IO_Self-published/Vref_resistor.sym} 0 1640 0 0 {name=x15}
C {design/IO_Self-published/StrongArmcmp.sym} 230 -1190 0 0 {name=x16}
C {devices/lab_pin.sym} 210 -1220 0 0 {name=p1 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 -1160 0 0 {name=p2 sig_type=std_logic lab=Vref0}
C {devices/lab_pin.sym} 290 -1270 0 0 {name=p3 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 -1110 0 0 {name=p4 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 -1110 2 0 {name=p5 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 -1190 2 0 {name=p6 sig_type=std_logic lab=Vout0}
C {design/IO_Self-published/StrongArmcmp.sym} 230 -1010 0 0 {name=x17}
C {devices/lab_pin.sym} 210 -1040 0 0 {name=p7 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 -980 0 0 {name=p8 sig_type=std_logic lab=Vref1}
C {devices/lab_pin.sym} 290 -1090 0 0 {name=p9 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 -930 0 0 {name=p10 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 -930 2 0 {name=p11 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 -1010 2 0 {name=p12 sig_type=std_logic lab=Vout1}
C {design/IO_Self-published/StrongArmcmp.sym} 230 -830 0 0 {name=x18}
C {devices/lab_pin.sym} 210 -860 0 0 {name=p13 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 -800 0 0 {name=p14 sig_type=std_logic lab=Vref2}
C {devices/lab_pin.sym} 290 -910 0 0 {name=p15 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 -750 0 0 {name=p16 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 -750 2 0 {name=p17 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 -830 2 0 {name=p18 sig_type=std_logic lab=Vout2}
C {design/IO_Self-published/StrongArmcmp.sym} 230 -650 0 0 {name=x19}
C {devices/lab_pin.sym} 210 -680 0 0 {name=p19 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 -620 0 0 {name=p20 sig_type=std_logic lab=Vref3}
C {devices/lab_pin.sym} 290 -730 0 0 {name=p21 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 -570 0 0 {name=p22 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 -570 2 0 {name=p23 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 -650 2 0 {name=p24 sig_type=std_logic lab=Vout3}
C {design/IO_Self-published/StrongArmcmp.sym} 230 -470 0 0 {name=x20}
C {devices/lab_pin.sym} 210 -500 0 0 {name=p25 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 -440 0 0 {name=p26 sig_type=std_logic lab=Vref4}
C {devices/lab_pin.sym} 290 -550 0 0 {name=p27 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 -390 0 0 {name=p28 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 -390 2 0 {name=p29 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 -470 2 0 {name=p30 sig_type=std_logic lab=Vout4}
C {design/IO_Self-published/StrongArmcmp.sym} 230 -290 0 0 {name=x21}
C {devices/lab_pin.sym} 210 -320 0 0 {name=p31 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 -260 0 0 {name=p32 sig_type=std_logic lab=Vref5}
C {devices/lab_pin.sym} 290 -370 0 0 {name=p33 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 -210 0 0 {name=p34 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 -210 2 0 {name=p35 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 -290 2 0 {name=p36 sig_type=std_logic lab=Vout5}
C {design/IO_Self-published/StrongArmcmp.sym} 230 -110 0 0 {name=x22}
C {devices/lab_pin.sym} 210 -140 0 0 {name=p37 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 -80 0 0 {name=p38 sig_type=std_logic lab=Vref6}
C {devices/lab_pin.sym} 290 -190 0 0 {name=p39 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 -30 0 0 {name=p40 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 -30 2 0 {name=p41 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 -110 2 0 {name=p42 sig_type=std_logic lab=Vout6}
C {design/IO_Self-published/StrongArmcmp.sym} 230 70 0 0 {name=x23}
C {devices/lab_pin.sym} 210 40 0 0 {name=p43 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 100 0 0 {name=p44 sig_type=std_logic lab=Vref7}
C {devices/lab_pin.sym} 290 -10 0 0 {name=p45 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 150 0 0 {name=p46 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 150 2 0 {name=p47 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 70 2 0 {name=p48 sig_type=std_logic lab=Vout7}
C {design/IO_Self-published/StrongArmcmp.sym} 230 250 0 0 {name=x24}
C {devices/lab_pin.sym} 210 220 0 0 {name=p49 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 280 0 0 {name=p50 sig_type=std_logic lab=Vref8}
C {devices/lab_pin.sym} 290 170 0 0 {name=p51 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 330 0 0 {name=p52 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 330 2 0 {name=p53 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 250 2 0 {name=p54 sig_type=std_logic lab=Vout8}
C {design/IO_Self-published/StrongArmcmp.sym} 230 430 0 0 {name=x25}
C {devices/lab_pin.sym} 210 400 0 0 {name=p55 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 460 0 0 {name=p56 sig_type=std_logic lab=Vref9}
C {devices/lab_pin.sym} 290 350 0 0 {name=p57 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 510 0 0 {name=p58 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 510 2 0 {name=p59 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 430 2 0 {name=p60 sig_type=std_logic lab=Vout9}
C {design/IO_Self-published/StrongArmcmp.sym} 230 610 0 0 {name=x26}
C {devices/lab_pin.sym} 210 580 0 0 {name=p61 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 640 0 0 {name=p62 sig_type=std_logic lab=Vref10}
C {devices/lab_pin.sym} 290 530 0 0 {name=p63 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 690 0 0 {name=p64 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 690 2 0 {name=p65 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 610 2 0 {name=p66 sig_type=std_logic lab=Vout10}
C {design/IO_Self-published/StrongArmcmp.sym} 230 790 0 0 {name=x27}
C {devices/lab_pin.sym} 210 760 0 0 {name=p67 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 820 0 0 {name=p68 sig_type=std_logic lab=Vref11}
C {devices/lab_pin.sym} 290 710 0 0 {name=p69 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 870 0 0 {name=p70 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 870 2 0 {name=p71 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 790 2 0 {name=p72 sig_type=std_logic lab=Vout11}
C {design/IO_Self-published/StrongArmcmp.sym} 230 970 0 0 {name=x28}
C {devices/lab_pin.sym} 210 940 0 0 {name=p73 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 1000 0 0 {name=p74 sig_type=std_logic lab=Vref12}
C {devices/lab_pin.sym} 290 890 0 0 {name=p75 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 1050 0 0 {name=p76 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 1050 2 0 {name=p77 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 970 2 0 {name=p78 sig_type=std_logic lab=Vout12}
C {design/IO_Self-published/StrongArmcmp.sym} 230 1150 0 0 {name=x29}
C {devices/lab_pin.sym} 210 1120 0 0 {name=p79 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 1180 0 0 {name=p80 sig_type=std_logic lab=Vref13}
C {devices/lab_pin.sym} 290 1070 0 0 {name=p81 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 1230 0 0 {name=p82 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 1230 2 0 {name=p83 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 1150 2 0 {name=p84 sig_type=std_logic lab=Vout13}
C {design/IO_Self-published/StrongArmcmp.sym} 230 1330 0 0 {name=x30}
C {devices/lab_pin.sym} 210 1300 0 0 {name=p85 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 1360 0 0 {name=p86 sig_type=std_logic lab=Vref14}
C {devices/lab_pin.sym} 290 1250 0 0 {name=p87 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 1410 0 0 {name=p88 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 1410 2 0 {name=p89 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 1330 2 0 {name=p90 sig_type=std_logic lab=Vout14}
C {design/IO_Self-published/StrongArmcmp.sym} 230 1510 0 0 {name=x31}
C {devices/lab_pin.sym} 210 1480 0 0 {name=p91 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 210 1540 0 0 {name=p92 sig_type=std_logic lab=Vref15}
C {devices/lab_pin.sym} 290 1430 0 0 {name=p93 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 1590 0 0 {name=p94 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 1590 2 0 {name=p95 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 1510 2 0 {name=p96 sig_type=std_logic lab=Vout15}
C {devices/lab_pin.sym} -140 -1160 0 0 {name=p97 sig_type=std_logic lab=Vref0}
C {devices/lab_pin.sym} -140 -980 0 0 {name=p99 sig_type=std_logic lab=Vref1}
C {devices/lab_pin.sym} -140 -800 0 0 {name=p101 sig_type=std_logic lab=Vref2}
C {devices/lab_pin.sym} -140 -620 0 0 {name=p103 sig_type=std_logic lab=Vref3}
C {devices/lab_pin.sym} -140 -440 0 0 {name=p105 sig_type=std_logic lab=Vref4}
C {devices/lab_pin.sym} -140 -260 0 0 {name=p107 sig_type=std_logic lab=Vref5}
C {devices/lab_pin.sym} -140 -80 0 0 {name=p109 sig_type=std_logic lab=Vref6}
C {devices/lab_pin.sym} -140 100 0 0 {name=p111 sig_type=std_logic lab=Vref7}
C {devices/lab_pin.sym} -140 280 0 0 {name=p113 sig_type=std_logic lab=Vref8}
C {devices/lab_pin.sym} -140 460 0 0 {name=p115 sig_type=std_logic lab=Vref9}
C {devices/lab_pin.sym} -140 640 0 0 {name=p117 sig_type=std_logic lab=Vref10}
C {devices/lab_pin.sym} -140 820 0 0 {name=p119 sig_type=std_logic lab=Vref11}
C {devices/lab_pin.sym} -140 1000 0 0 {name=p121 sig_type=std_logic lab=Vref12}
C {devices/lab_pin.sym} -140 1180 0 0 {name=p123 sig_type=std_logic lab=Vref13}
C {devices/lab_pin.sym} -140 1360 0 0 {name=p125 sig_type=std_logic lab=Vref14}
C {devices/lab_pin.sym} -140 1540 0 0 {name=p127 sig_type=std_logic lab=Vref15}
C {devices/vsource.sym} -430 -1260 0 0 {name=Vdd value=5 savecurrent=false}
C {devices/gnd.sym} -430 -1220 0 0 {name=l3 lab=GND}
C {devices/vdd.sym} -430 -1300 0 0 {name=l4 lab=VDD}
C {devices/vsource.sym} -320 -1260 0 0 {name=Vdd1 value=3.4 savecurrent=false}
C {devices/gnd.sym} -320 -1210 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} -320 -1220 0 0 {name=p98 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} -320 -1310 0 0 {name=p100 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 0 -1300 0 0 {name=p102 sig_type=std_logic lab=GND}
C {devices/vsource.sym} -430 -1100 0 0 {name=Vdd2 value=1 savecurrent=false}
C {devices/gnd.sym} -430 -1060 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} -430 -1150 0 0 {name=p106 sig_type=std_logic lab=Vbias}
C {devices/vsource.sym} -320 -1100 0 0 {name=vin value=2.5 savecurrent=false}
C {devices/gnd.sym} -320 -1060 0 0 {name=l5 lab=GND}
C {devices/lab_pin.sym} -320 -1150 0 0 {name=p108 sig_type=std_logic lab=Vin}
C {devices/code.sym} -490 -1570 0 0 {name=TR10_MODELS
only_toplevel=true
format="tcleval( @value )"
value=".include $::LIB/../ip62_models"
spice_ignore=false}
C {devices/code_shown.sym} -210 -1640 0 0 {name=spice only_toplevel=false value=".option savecurrent
.control
save all

* DC analysis (I/O curve)
dc vin 0 3.4 0.001
*tran 1n 10u
plot Vout0 Vout1 Vout2 Vout3 Vout4 Vout5 Vout6 Vout7 Vout8 Vout9 Vout10 Vout11 Vout12 Vout13 Vout14 Vout15
+ Vout16 Vout17 Vout18 Vout19 Vout20 Vout21 Vout22 Vout23 Vout24 Vout25 Vout26 Vout27 Vout28 Vout29 Vout30 Vout31 
plot Vref0 Vref1 Vref2 Vref3 Vref4 Vref5 Vref6 Vref7 Vref8 Vref9 Vref10 Vref11 Vref12 Vref13 Vref14 Vref15
+ Vref16 Vref17 Vref18 Vref19 Vref20 Vref21 Vref22 Vref23 Vref24 Vref25 Vref26 Vref27 Vref28 Vref29 Vref30 Vref31 Vin
plot Out0 / 5 + Out1 / 5 * 2 + Out2 / 5 * 4 + Out3 / 5 * 8 + Out4 / 5 * 16
gnuplot gp Out0 / 5 + Out1 / 5 * 2 + Out2 / 5 * 4 + Out3 / 5 * 8 + Out4 / 5 * 16
* plot i(vd)
* wrdata ~/inverter_tb.txt v(vout)
* write inverter_tb.raw
.endc"}
C {design/IO_Self-published/Vref_resistor.sym} 0 1810 0 0 {name=x32}
C {design/IO_Self-published/Vref_resistor.sym} 0 1990 0 0 {name=x33}
C {design/IO_Self-published/Vref_resistor.sym} 0 2170 0 0 {name=x34}
C {design/IO_Self-published/Vref_resistor.sym} 0 2350 0 0 {name=x35}
C {design/IO_Self-published/Vref_resistor.sym} 0 2530 0 0 {name=x36}
C {design/IO_Self-published/Vref_resistor.sym} 0 2710 0 0 {name=x37}
C {design/IO_Self-published/Vref_resistor.sym} 0 2890 0 0 {name=x38}
C {design/IO_Self-published/Vref_resistor.sym} 0 3060 0 0 {name=x39}
C {design/IO_Self-published/Vref_resistor.sym} 0 3240 0 0 {name=x40}
C {design/IO_Self-published/Vref_resistor.sym} 0 3440 0 0 {name=x41}
C {design/IO_Self-published/Vref_resistor.sym} 0 3610 0 0 {name=x42}
C {design/IO_Self-published/Vref_resistor.sym} 0 3790 0 0 {name=x43}
C {design/IO_Self-published/Vref_resistor.sym} 0 3970 0 0 {name=x44}
C {design/IO_Self-published/Vref_resistor.sym} 0 4150 0 0 {name=x45}
C {design/IO_Self-published/Vref_resistor.sym} 0 4330 0 0 {name=x46}
C {design/IO_Self-published/StrongArmcmp.sym} 230 1690 0 0 {name=x48}
C {devices/lab_pin.sym} 210 1660 0 0 {name=p110 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 1610 0 0 {name=p114 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 1770 0 0 {name=p116 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 1770 2 0 {name=p118 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 1690 2 0 {name=p120 sig_type=std_logic lab=Vout16}
C {design/IO_Self-published/StrongArmcmp.sym} 230 1870 0 0 {name=x49}
C {devices/lab_pin.sym} 210 1840 0 0 {name=p122 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 1790 0 0 {name=p126 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 1950 0 0 {name=p128 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 1950 2 0 {name=p129 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 1870 2 0 {name=p130 sig_type=std_logic lab=Vout17}
C {design/IO_Self-published/StrongArmcmp.sym} 230 2050 0 0 {name=x50}
C {devices/lab_pin.sym} 210 2020 0 0 {name=p131 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 1970 0 0 {name=p133 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 2130 0 0 {name=p134 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 2130 2 0 {name=p135 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 2050 2 0 {name=p136 sig_type=std_logic lab=Vout18}
C {design/IO_Self-published/StrongArmcmp.sym} 230 2230 0 0 {name=x51}
C {devices/lab_pin.sym} 210 2200 0 0 {name=p137 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 2150 0 0 {name=p139 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 2310 0 0 {name=p140 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 2310 2 0 {name=p141 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 2230 2 0 {name=p142 sig_type=std_logic lab=Vout19}
C {design/IO_Self-published/StrongArmcmp.sym} 230 2410 0 0 {name=x52}
C {devices/lab_pin.sym} 210 2380 0 0 {name=p143 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 2330 0 0 {name=p145 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 2490 0 0 {name=p146 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 2490 2 0 {name=p147 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 2410 2 0 {name=p148 sig_type=std_logic lab=Vout20}
C {design/IO_Self-published/StrongArmcmp.sym} 230 2590 0 0 {name=x53}
C {devices/lab_pin.sym} 210 2560 0 0 {name=p149 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 2510 0 0 {name=p151 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 2670 0 0 {name=p152 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 2670 2 0 {name=p153 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 2590 2 0 {name=p154 sig_type=std_logic lab=Vout21}
C {design/IO_Self-published/StrongArmcmp.sym} 230 2770 0 0 {name=x54}
C {devices/lab_pin.sym} 210 2740 0 0 {name=p155 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 2690 0 0 {name=p157 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 2850 0 0 {name=p158 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 2850 2 0 {name=p159 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 2770 2 0 {name=p160 sig_type=std_logic lab=Vout22}
C {design/IO_Self-published/StrongArmcmp.sym} 230 2950 0 0 {name=x55}
C {devices/lab_pin.sym} 210 2920 0 0 {name=p161 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 2870 0 0 {name=p163 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 3030 0 0 {name=p164 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 3030 2 0 {name=p165 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 2950 2 0 {name=p166 sig_type=std_logic lab=Vout23}
C {design/IO_Self-published/StrongArmcmp.sym} 230 3130 0 0 {name=x56}
C {devices/lab_pin.sym} 210 3100 0 0 {name=p167 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 3050 0 0 {name=p169 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 3210 0 0 {name=p170 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 3210 2 0 {name=p171 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 3130 2 0 {name=p172 sig_type=std_logic lab=Vout24}
C {design/IO_Self-published/StrongArmcmp.sym} 230 3310 0 0 {name=x57}
C {devices/lab_pin.sym} 210 3280 0 0 {name=p173 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 3230 0 0 {name=p175 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 3390 0 0 {name=p176 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 3390 2 0 {name=p177 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 3310 2 0 {name=p178 sig_type=std_logic lab=Vout25}
C {design/IO_Self-published/StrongArmcmp.sym} 230 3490 0 0 {name=x58}
C {devices/lab_pin.sym} 210 3460 0 0 {name=p179 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 3410 0 0 {name=p181 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 3570 0 0 {name=p182 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 3570 2 0 {name=p183 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 3490 2 0 {name=p184 sig_type=std_logic lab=Vout26}
C {design/IO_Self-published/StrongArmcmp.sym} 230 3670 0 0 {name=x59}
C {devices/lab_pin.sym} 210 3640 0 0 {name=p185 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 3590 0 0 {name=p187 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 3750 0 0 {name=p188 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 3750 2 0 {name=p189 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 3670 2 0 {name=p190 sig_type=std_logic lab=Vout27}
C {design/IO_Self-published/StrongArmcmp.sym} 230 3850 0 0 {name=x60}
C {devices/lab_pin.sym} 210 3820 0 0 {name=p191 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 3770 0 0 {name=p193 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 3930 0 0 {name=p194 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 3930 2 0 {name=p195 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 3850 2 0 {name=p196 sig_type=std_logic lab=Vout28}
C {design/IO_Self-published/StrongArmcmp.sym} 230 4030 0 0 {name=x61}
C {devices/lab_pin.sym} 210 4000 0 0 {name=p197 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 3950 0 0 {name=p199 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 4110 0 0 {name=p200 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 4110 2 0 {name=p201 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 4030 2 0 {name=p202 sig_type=std_logic lab=Vout29}
C {design/IO_Self-published/StrongArmcmp.sym} 230 4210 0 0 {name=x62}
C {devices/lab_pin.sym} 210 4180 0 0 {name=p203 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 4130 0 0 {name=p205 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 4290 0 0 {name=p206 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 4290 2 0 {name=p207 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 4210 2 0 {name=p208 sig_type=std_logic lab=Vout30}
C {design/IO_Self-published/StrongArmcmp.sym} 230 4390 0 0 {name=x63}
C {devices/lab_pin.sym} 210 4360 0 0 {name=p209 sig_type=std_logic lab=Vin}
C {devices/lab_pin.sym} 290 4310 0 0 {name=p211 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 290 4470 0 0 {name=p212 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 330 4470 2 0 {name=p213 sig_type=std_logic lab=Vbias}
C {devices/lab_pin.sym} 410 4390 2 0 {name=p214 sig_type=std_logic lab=Vout31}
C {devices/lab_pin.sym} -140 1720 0 0 {name=p215 sig_type=std_logic lab=Vref16}
C {devices/lab_pin.sym} -140 1900 0 0 {name=p216 sig_type=std_logic lab=Vref17}
C {devices/lab_pin.sym} -140 2080 0 0 {name=p217 sig_type=std_logic lab=Vref18}
C {devices/lab_pin.sym} -140 2260 0 0 {name=p218 sig_type=std_logic lab=Vref19}
C {devices/lab_pin.sym} -140 2440 0 0 {name=p219 sig_type=std_logic lab=Vref20}
C {devices/lab_pin.sym} -140 2620 0 0 {name=p220 sig_type=std_logic lab=Vref21}
C {devices/lab_pin.sym} -140 2800 0 0 {name=p221 sig_type=std_logic lab=Vref22}
C {devices/lab_pin.sym} -140 2980 0 0 {name=p222 sig_type=std_logic lab=Vref23}
C {devices/lab_pin.sym} -140 3160 0 0 {name=p223 sig_type=std_logic lab=Vref24}
C {devices/lab_pin.sym} -140 3340 0 0 {name=p224 sig_type=std_logic lab=Vref25}
C {devices/lab_pin.sym} -140 3520 0 0 {name=p225 sig_type=std_logic lab=Vref26}
C {devices/lab_pin.sym} -140 3700 0 0 {name=p226 sig_type=std_logic lab=Vref27}
C {devices/lab_pin.sym} -140 3880 0 0 {name=p227 sig_type=std_logic lab=Vref28}
C {devices/lab_pin.sym} -140 4060 0 0 {name=p228 sig_type=std_logic lab=Vref29}
C {devices/lab_pin.sym} -140 4240 0 0 {name=p229 sig_type=std_logic lab=Vref30}
C {devices/lab_pin.sym} -140 4420 0 0 {name=p230 sig_type=std_logic lab=Vref31}
C {devices/lab_pin.sym} 0 4580 0 0 {name=p104 sig_type=std_logic lab=Vref}
C {devices/lab_pin.sym} 210 1720 0 0 {name=p231 sig_type=std_logic lab=Vref16}
C {devices/lab_pin.sym} 210 1900 0 0 {name=p232 sig_type=std_logic lab=Vref17}
C {devices/lab_pin.sym} 210 2080 0 0 {name=p233 sig_type=std_logic lab=Vref18}
C {devices/lab_pin.sym} 210 2260 0 0 {name=p234 sig_type=std_logic lab=Vref19}
C {devices/lab_pin.sym} 210 2440 0 0 {name=p235 sig_type=std_logic lab=Vref20}
C {devices/lab_pin.sym} 210 2620 0 0 {name=p236 sig_type=std_logic lab=Vref21}
C {devices/lab_pin.sym} 210 2800 0 0 {name=p237 sig_type=std_logic lab=Vref22}
C {devices/lab_pin.sym} 210 2980 0 0 {name=p238 sig_type=std_logic lab=Vref23}
C {devices/lab_pin.sym} 210 3160 0 0 {name=p239 sig_type=std_logic lab=Vref24}
C {devices/lab_pin.sym} 210 3340 0 0 {name=p240 sig_type=std_logic lab=Vref25}
C {devices/lab_pin.sym} 210 3520 0 0 {name=p241 sig_type=std_logic lab=Vref26}
C {devices/lab_pin.sym} 210 3700 0 0 {name=p242 sig_type=std_logic lab=Vref27}
C {devices/lab_pin.sym} 210 3880 0 0 {name=p243 sig_type=std_logic lab=Vref28}
C {devices/lab_pin.sym} 210 4060 0 0 {name=p244 sig_type=std_logic lab=Vref29}
C {devices/lab_pin.sym} 210 4240 0 0 {name=p245 sig_type=std_logic lab=Vref30}
C {devices/lab_pin.sym} 210 4420 0 0 {name=p246 sig_type=std_logic lab=Vref31}
C {design/IO_Self-published/AND_Ainv.sym} 660 -1180 0 0 {name=x64}
C {devices/lab_pin.sym} 690 -1260 0 0 {name=p112 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 -1100 0 0 {name=p124 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 -1160 2 1 {name=p132 sig_type=std_logic lab=Vout0}
C {devices/lab_pin.sym} 600 -1200 2 1 {name=p138 sig_type=std_logic lab=Vout1}
C {design/IO_Self-published/AND_Ainv.sym} 660 -1000 0 0 {name=x65}
C {devices/lab_pin.sym} 690 -1080 0 0 {name=p144 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 -920 0 0 {name=p150 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 -980 2 1 {name=p156 sig_type=std_logic lab=Vout1}
C {devices/lab_pin.sym} 600 -1020 2 1 {name=p162 sig_type=std_logic lab=Vout2}
C {design/IO_Self-published/AND_Ainv.sym} 660 -810 0 0 {name=x66}
C {devices/lab_pin.sym} 690 -890 0 0 {name=p168 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 -730 0 0 {name=p174 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 -790 2 1 {name=p180 sig_type=std_logic lab=Vout2}
C {devices/lab_pin.sym} 600 -830 2 1 {name=p186 sig_type=std_logic lab=Vout3}
C {design/IO_Self-published/AND_Ainv.sym} 660 -630 0 0 {name=x67}
C {devices/lab_pin.sym} 690 -710 0 0 {name=p192 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 -550 0 0 {name=p198 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 -610 2 1 {name=p204 sig_type=std_logic lab=Vout3}
C {devices/lab_pin.sym} 600 -650 2 1 {name=p210 sig_type=std_logic lab=Vout4}
C {design/IO_Self-published/AND_Ainv.sym} 660 -450 0 0 {name=x68}
C {devices/lab_pin.sym} 690 -530 0 0 {name=p247 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 -370 0 0 {name=p248 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 -430 2 1 {name=p249 sig_type=std_logic lab=Vout4}
C {devices/lab_pin.sym} 600 -470 2 1 {name=p250 sig_type=std_logic lab=Vout5}
C {design/IO_Self-published/AND_Ainv.sym} 660 -270 0 0 {name=x69}
C {devices/lab_pin.sym} 690 -350 0 0 {name=p251 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 -190 0 0 {name=p252 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 -250 2 1 {name=p253 sig_type=std_logic lab=Vout5}
C {devices/lab_pin.sym} 600 -290 2 1 {name=p254 sig_type=std_logic lab=Vout6}
C {design/IO_Self-published/AND_Ainv.sym} 660 -90 0 0 {name=x70}
C {devices/lab_pin.sym} 690 -170 0 0 {name=p255 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 -10 0 0 {name=p256 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 -70 2 1 {name=p257 sig_type=std_logic lab=Vout6}
C {devices/lab_pin.sym} 600 -110 2 1 {name=p258 sig_type=std_logic lab=Vout7}
C {design/IO_Self-published/AND_Ainv.sym} 660 90 0 0 {name=x71}
C {devices/lab_pin.sym} 690 10 0 0 {name=p259 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 170 0 0 {name=p260 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 110 2 1 {name=p261 sig_type=std_logic lab=Vout7}
C {devices/lab_pin.sym} 600 70 2 1 {name=p262 sig_type=std_logic lab=Vout8}
C {design/IO_Self-published/AND_Ainv.sym} 660 270 0 0 {name=x72}
C {devices/lab_pin.sym} 690 190 0 0 {name=p263 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 350 0 0 {name=p264 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 290 2 1 {name=p265 sig_type=std_logic lab=Vout8}
C {devices/lab_pin.sym} 600 250 2 1 {name=p266 sig_type=std_logic lab=Vout9}
C {design/IO_Self-published/AND_Ainv.sym} 660 450 0 0 {name=x73}
C {devices/lab_pin.sym} 690 370 0 0 {name=p267 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 530 0 0 {name=p268 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 470 2 1 {name=p269 sig_type=std_logic lab=Vout9}
C {devices/lab_pin.sym} 600 430 2 1 {name=p270 sig_type=std_logic lab=Vout10}
C {design/IO_Self-published/AND_Ainv.sym} 660 630 0 0 {name=x74}
C {devices/lab_pin.sym} 690 550 0 0 {name=p271 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 710 0 0 {name=p272 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 650 2 1 {name=p273 sig_type=std_logic lab=Vout10}
C {devices/lab_pin.sym} 600 610 2 1 {name=p274 sig_type=std_logic lab=Vout11
}
C {design/IO_Self-published/AND_Ainv.sym} 660 810 0 0 {name=x75}
C {devices/lab_pin.sym} 690 730 0 0 {name=p275 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 890 0 0 {name=p276 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 830 2 1 {name=p277 sig_type=std_logic lab=Vout11}
C {devices/lab_pin.sym} 600 790 2 1 {name=p278 sig_type=std_logic lab=Vout12}
C {design/IO_Self-published/AND_Ainv.sym} 660 990 0 0 {name=x76}
C {devices/lab_pin.sym} 690 910 0 0 {name=p279 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 1070 0 0 {name=p280 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 1010 2 1 {name=p281 sig_type=std_logic lab=Vout12}
C {devices/lab_pin.sym} 600 970 2 1 {name=p282 sig_type=std_logic lab=Vout13}
C {design/IO_Self-published/AND_Ainv.sym} 660 1180 0 0 {name=x77}
C {devices/lab_pin.sym} 690 1100 0 0 {name=p283 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 1260 0 0 {name=p284 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 1200 2 1 {name=p285 sig_type=std_logic lab=Vout13}
C {devices/lab_pin.sym} 600 1160 2 1 {name=p286 sig_type=std_logic lab=Vout14}
C {design/IO_Self-published/AND_Ainv.sym} 660 1360 0 0 {name=x78}
C {devices/lab_pin.sym} 690 1280 0 0 {name=p287 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 1440 0 0 {name=p288 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 1380 2 1 {name=p289 sig_type=std_logic lab=Vout14}
C {devices/lab_pin.sym} 600 1340 2 1 {name=p290 sig_type=std_logic lab=Vout15}
C {design/IO_Self-published/AND_Ainv.sym} 660 1540 0 0 {name=x79}
C {devices/lab_pin.sym} 690 1460 0 0 {name=p291 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 1620 0 0 {name=p292 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 1560 2 1 {name=p293 sig_type=std_logic lab=Vout15}
C {devices/lab_pin.sym} 600 1520 2 1 {name=p294 sig_type=std_logic lab=Vout16}
C {design/IO_Self-published/AND_Ainv.sym} 660 1720 0 0 {name=x80}
C {devices/lab_pin.sym} 690 1640 0 0 {name=p295 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 1800 0 0 {name=p296 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 1740 2 1 {name=p297 sig_type=std_logic lab=Vout16}
C {devices/lab_pin.sym} 600 1700 2 1 {name=p298 sig_type=std_logic lab=Vout17}
C {design/IO_Self-published/AND_Ainv.sym} 660 1900 0 0 {name=x81}
C {devices/lab_pin.sym} 690 1820 0 0 {name=p299 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 1980 0 0 {name=p300 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 1920 2 1 {name=p301 sig_type=std_logic lab=Vout17}
C {devices/lab_pin.sym} 600 1880 2 1 {name=p302 sig_type=std_logic lab=Vout18}
C {design/IO_Self-published/AND_Ainv.sym} 660 2080 0 0 {name=x82}
C {devices/lab_pin.sym} 690 2000 0 0 {name=p303 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 2160 0 0 {name=p304 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 2100 2 1 {name=p305 sig_type=std_logic lab=Vout18}
C {devices/lab_pin.sym} 600 2060 2 1 {name=p306 sig_type=std_logic lab=Vout19}
C {design/IO_Self-published/AND_Ainv.sym} 660 2260 0 0 {name=x83}
C {devices/lab_pin.sym} 690 2180 0 0 {name=p307 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 2340 0 0 {name=p308 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 2280 2 1 {name=p309 sig_type=std_logic lab=Vout19}
C {devices/lab_pin.sym} 600 2240 2 1 {name=p310 sig_type=std_logic lab=Vout20}
C {design/IO_Self-published/AND_Ainv.sym} 660 2440 0 0 {name=x84}
C {devices/lab_pin.sym} 690 2360 0 0 {name=p311 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 2520 0 0 {name=p312 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 2460 2 1 {name=p313 sig_type=std_logic lab=Vout20}
C {devices/lab_pin.sym} 600 2420 2 1 {name=p314 sig_type=std_logic lab=Vout21}
C {design/IO_Self-published/AND_Ainv.sym} 660 2620 0 0 {name=x85}
C {devices/lab_pin.sym} 690 2540 0 0 {name=p315 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 2700 0 0 {name=p316 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 2640 2 1 {name=p317 sig_type=std_logic lab=Vout21}
C {devices/lab_pin.sym} 600 2600 2 1 {name=p318 sig_type=std_logic lab=Vout22}
C {design/IO_Self-published/AND_Ainv.sym} 660 2800 0 0 {name=x86}
C {devices/lab_pin.sym} 690 2720 0 0 {name=p319 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 2880 0 0 {name=p320 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 2820 2 1 {name=p321 sig_type=std_logic lab=Vout22}
C {devices/lab_pin.sym} 600 2780 2 1 {name=p322 sig_type=std_logic lab=Vout23}
C {design/IO_Self-published/AND_Ainv.sym} 660 2980 0 0 {name=x87}
C {devices/lab_pin.sym} 690 2900 0 0 {name=p323 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 3060 0 0 {name=p324 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 3000 2 1 {name=p325 sig_type=std_logic lab=Vout23}
C {devices/lab_pin.sym} 600 2960 2 1 {name=p326 sig_type=std_logic lab=Vout24}
C {design/IO_Self-published/AND_Ainv.sym} 660 3160 0 0 {name=x88}
C {devices/lab_pin.sym} 690 3080 0 0 {name=p327 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 3240 0 0 {name=p328 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 3180 2 1 {name=p329 sig_type=std_logic lab=Vout24}
C {devices/lab_pin.sym} 600 3140 2 1 {name=p330 sig_type=std_logic lab=Vout25}
C {design/IO_Self-published/AND_Ainv.sym} 660 3340 0 0 {name=x89}
C {devices/lab_pin.sym} 690 3260 0 0 {name=p331 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 3420 0 0 {name=p332 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 3360 2 1 {name=p333 sig_type=std_logic lab=Vout25}
C {devices/lab_pin.sym} 600 3320 2 1 {name=p334 sig_type=std_logic lab=Vout26}
C {design/IO_Self-published/AND_Ainv.sym} 660 3520 0 0 {name=x90}
C {devices/lab_pin.sym} 690 3440 0 0 {name=p335 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 3600 0 0 {name=p336 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 3540 2 1 {name=p337 sig_type=std_logic lab=Vout26}
C {devices/lab_pin.sym} 600 3500 2 1 {name=p338 sig_type=std_logic lab=Vout27}
C {design/IO_Self-published/AND_Ainv.sym} 660 3700 0 0 {name=x91}
C {devices/lab_pin.sym} 690 3620 0 0 {name=p339 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 3780 0 0 {name=p340 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 3720 2 1 {name=p341 sig_type=std_logic lab=Vout27}
C {devices/lab_pin.sym} 600 3680 2 1 {name=p342 sig_type=std_logic lab=Vout28}
C {design/IO_Self-published/AND_Ainv.sym} 660 3880 0 0 {name=x92}
C {devices/lab_pin.sym} 690 3800 0 0 {name=p343 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 3960 0 0 {name=p344 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 3900 2 1 {name=p345 sig_type=std_logic lab=Vout28}
C {devices/lab_pin.sym} 600 3860 2 1 {name=p346 sig_type=std_logic lab=Vout29}
C {design/IO_Self-published/AND_Ainv.sym} 660 4060 0 0 {name=x93}
C {devices/lab_pin.sym} 690 3980 0 0 {name=p347 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 4140 0 0 {name=p348 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 4080 2 1 {name=p349 sig_type=std_logic lab=Vout29}
C {devices/lab_pin.sym} 600 4040 2 1 {name=p350 sig_type=std_logic lab=Vout30}
C {design/IO_Self-published/AND_Ainv.sym} 660 4240 0 0 {name=x94}
C {devices/lab_pin.sym} 690 4160 0 0 {name=p351 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 4320 0 0 {name=p352 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 4220 2 1 {name=p354 sig_type=std_logic lab=Vout31}
C {devices/lab_pin.sym} 600 4260 0 0 {name=p355 sig_type=std_logic lab=Vout30}
C {devices/lab_pin.sym} 1110 -1220 2 0 {name=p353 sig_type=std_logic lab=VDD}
C {design/IO_Self-published/Fat_tree_encoder.sym} 1110 -860 0 0 {name=x95}
C {devices/lab_pin.sym} 1110 -500 2 0 {name=p356 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 1230 -1100 2 0 {name=p357 sig_type=std_logic lab=Out0}
C {devices/lab_pin.sym} 1230 -1080 2 0 {name=p358 sig_type=std_logic lab=Out1}
C {devices/lab_pin.sym} 1230 -1060 2 0 {name=p359 sig_type=std_logic lab=Out2}
C {devices/lab_pin.sym} 1230 -1040 2 0 {name=p360 sig_type=std_logic lab=Out3}
C {devices/lab_pin.sym} 1230 -1020 2 0 {name=p361 sig_type=std_logic lab=Out4}
C {devices/lab_pin.sym} 980 -1170 2 1 {name=p362 sig_type=std_logic lab=CN0 }
C {devices/lab_pin.sym} 980 -1150 2 1 {name=p363 sig_type=std_logic lab=CN1}
C {devices/lab_pin.sym} 980 -1130 2 1 {name=p364 sig_type=std_logic lab=CN2}
C {devices/lab_pin.sym} 980 -1110 2 1 {name=p365 sig_type=std_logic lab=CN3}
C {devices/lab_pin.sym} 980 -1090 2 1 {name=p366 sig_type=std_logic lab=CN4}
C {devices/lab_pin.sym} 980 -1070 2 1 {name=p367 sig_type=std_logic lab=CN5}
C {devices/lab_pin.sym} 980 -1050 2 1 {name=p368 sig_type=std_logic lab=CN6}
C {devices/lab_pin.sym} 980 -1030 2 1 {name=p369 sig_type=std_logic lab=CN7}
C {devices/lab_pin.sym} 980 -1010 2 1 {name=p370 sig_type=std_logic lab=CN8}
C {devices/lab_pin.sym} 980 -990 2 1 {name=p371 sig_type=std_logic lab=CN9}
C {devices/lab_pin.sym} 980 -970 2 1 {name=p372 sig_type=std_logic lab=CN10}
C {devices/lab_pin.sym} 980 -950 2 1 {name=p373 sig_type=std_logic lab=CN11}
C {devices/lab_pin.sym} 980 -930 2 1 {name=p374 sig_type=std_logic lab=CN12}
C {devices/lab_pin.sym} 980 -910 2 1 {name=p375 sig_type=std_logic lab=CN13}
C {devices/lab_pin.sym} 980 -890 2 1 {name=p376 sig_type=std_logic lab=CN14
}
C {devices/lab_pin.sym} 980 -870 2 1 {name=p377 sig_type=std_logic lab=CN15}
C {devices/lab_pin.sym} 980 -850 2 1 {name=p378 sig_type=std_logic lab=CN16}
C {devices/lab_pin.sym} 980 -830 2 1 {name=p379 sig_type=std_logic lab=CN17}
C {devices/lab_pin.sym} 980 -810 2 1 {name=p380 sig_type=std_logic lab=CN18}
C {devices/lab_pin.sym} 980 -790 2 1 {name=p382 sig_type=std_logic lab=CN19}
C {devices/lab_pin.sym} 980 -770 2 1 {name=p383 sig_type=std_logic lab=CN20 }
C {devices/lab_pin.sym} 980 -750 2 1 {name=p384 sig_type=std_logic lab=CN21}
C {devices/lab_pin.sym} 980 -730 2 1 {name=p385 sig_type=std_logic lab=CN22 }
C {devices/lab_pin.sym} 980 -710 2 1 {name=p386 sig_type=std_logic lab=CN23}
C {devices/lab_pin.sym} 980 -690 2 1 {name=p387 sig_type=std_logic lab=CN24}
C {devices/lab_pin.sym} 980 -670 2 1 {name=p388 sig_type=std_logic lab=CN25 }
C {devices/lab_pin.sym} 980 -650 2 1 {name=p389 sig_type=std_logic lab=CN26 }
C {devices/lab_pin.sym} 980 -630 2 1 {name=p390 sig_type=std_logic lab=CN27}
C {devices/lab_pin.sym} 980 -590 2 1 {name=p391 sig_type=std_logic lab=CN29}
C {devices/lab_pin.sym} 980 -570 2 1 {name=p392 sig_type=std_logic lab=CN30}
C {devices/lab_pin.sym} 980 -550 2 1 {name=p393 sig_type=std_logic lab=CN31 }
C {devices/lab_pin.sym} 980 -610 2 1 {name=p381 sig_type=std_logic lab=CN28}
C {devices/lab_pin.sym} 790 -1180 2 0 {name=p394 sig_type=std_logic lab=CN0 }
C {devices/lab_pin.sym} 790 -1000 2 0 {name=p395 sig_type=std_logic lab=CN1}
C {devices/lab_pin.sym} 790 -810 2 0 {name=p396 sig_type=std_logic lab=CN2}
C {devices/lab_pin.sym} 790 -630 2 0 {name=p397 sig_type=std_logic lab=CN3}
C {devices/lab_pin.sym} 790 -450 2 0 {name=p398 sig_type=std_logic lab=CN4}
C {devices/lab_pin.sym} 790 -270 2 0 {name=p399 sig_type=std_logic lab=CN5}
C {devices/lab_pin.sym} 790 -90 2 0 {name=p400 sig_type=std_logic lab=CN6}
C {devices/lab_pin.sym} 790 90 2 0 {name=p401 sig_type=std_logic lab=CN7}
C {devices/lab_pin.sym} 790 270 2 0 {name=p402 sig_type=std_logic lab=CN8}
C {devices/lab_pin.sym} 790 450 2 0 {name=p403 sig_type=std_logic lab=CN9}
C {devices/lab_pin.sym} 790 630 2 0 {name=p404 sig_type=std_logic lab=CN10}
C {devices/lab_pin.sym} 790 810 2 0 {name=p405 sig_type=std_logic lab=CN11}
C {devices/lab_pin.sym} 790 990 2 0 {name=p406 sig_type=std_logic lab=CN12}
C {devices/lab_pin.sym} 790 1180 2 0 {name=p407 sig_type=std_logic lab=CN13}
C {devices/lab_pin.sym} 790 1360 2 0 {name=p408 sig_type=std_logic lab=CN14
}
C {devices/lab_pin.sym} 790 1540 2 0 {name=p409 sig_type=std_logic lab=CN15}
C {devices/lab_pin.sym} 790 1720 2 0 {name=p410 sig_type=std_logic lab=CN16}
C {devices/lab_pin.sym} 790 1900 2 0 {name=p411 sig_type=std_logic lab=CN17}
C {devices/lab_pin.sym} 790 2080 2 0 {name=p412 sig_type=std_logic lab=CN18}
C {devices/lab_pin.sym} 790 2260 2 0 {name=p413 sig_type=std_logic lab=CN19}
C {devices/lab_pin.sym} 790 2440 2 0 {name=p414 sig_type=std_logic lab=CN20 }
C {devices/lab_pin.sym} 790 2620 2 0 {name=p415 sig_type=std_logic lab=CN21}
C {devices/lab_pin.sym} 790 2800 2 0 {name=p416 sig_type=std_logic lab=CN22 }
C {devices/lab_pin.sym} 790 2980 2 0 {name=p417 sig_type=std_logic lab=CN23}
C {devices/lab_pin.sym} 790 3160 2 0 {name=p418 sig_type=std_logic lab=CN24}
C {devices/lab_pin.sym} 790 3340 2 0 {name=p419 sig_type=std_logic lab=CN25 }
C {devices/lab_pin.sym} 790 3520 2 0 {name=p420 sig_type=std_logic lab=CN26 }
C {devices/lab_pin.sym} 790 3700 2 0 {name=p421 sig_type=std_logic lab=CN27}
C {devices/lab_pin.sym} 790 4060 2 0 {name=p422 sig_type=std_logic lab=CN29}
C {devices/lab_pin.sym} 790 4240 2 0 {name=p423 sig_type=std_logic lab=CN30}
C {devices/lab_pin.sym} 790 4420 2 0 {name=p424 sig_type=std_logic lab=CN31 }
C {devices/lab_pin.sym} 790 3880 2 0 {name=p425 sig_type=std_logic lab=CN28}
C {design/IO_Self-published/AND_Ainv.sym} 660 4420 0 0 {name=x96}
C {devices/lab_pin.sym} 690 4340 0 0 {name=p426 sig_type=std_logic lab=VDD}
C {devices/lab_pin.sym} 690 4500 0 0 {name=p427 sig_type=std_logic lab=GND}
C {devices/lab_pin.sym} 600 4440 2 1 {name=p428 sig_type=std_logic lab=Vout31}
C {devices/lab_pin.sym} 600 4400 0 0 {name=p429 sig_type=std_logic lab=GND}
C {IP62LIB/RS.sym} -60 -1270 0 0 {name=R1
w=4e-6
R=1
l=100e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0}
C {IP62LIB/RS.sym} 40 -1270 0 0 {name=R2
w=4e-6
R=1
l=100e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0}
C {IP62LIB/RS.sym} -60 4490 0 0 {name=R3
w=4e-6
R=1
l=100e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0}
C {IP62LIB/RS.sym} 40 4490 0 0 {name=R4
w=4e-6
R=1
l=100e-6
model=F_RS
spiceprefix=X
tc1=0
tc2=0}
